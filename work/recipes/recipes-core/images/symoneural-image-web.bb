# Clean-target proof image for the web runtime: a rootfs assembled by opkg from the
# package feed containing packagegroup-symoneural-web and its RDEPENDS. No source tree,
# no devtool workspace, no pip, no build frontends, no weights.
# GENERATED by scripts/generate-runtime-images.py.
#
# python3-modules is for the HARNESS: work/tools/clean-root-proof runs a Python proof body
# under the target loader and refuses a root without an interpreter. It is not part of the
# web surface; the manifest's symoneural-* rows are.
SUMMARY = "SyMoNeuRaL web clean-root proof image"
LICENSE = "MIT"

inherit image

IMAGE_INSTALL = "packagegroup-symoneural-web python3-modules"
IMAGE_FEATURES = ""
IMAGE_LINGUAS = ""
IMAGE_FSTYPES = "tar.gz"
IMAGE_INSTALL:remove = "packagegroup-core-boot"
NO_RECOMMENDATIONS = "1"
# no qemuboot and no kernel: nothing boots this tarball (see symoneural-image-api)
IMAGE_CLASSES:remove = "qemuboot"
KERNEL_DEPLOY_DEPEND = ""
KERNELDEPMODDEPEND = ""
