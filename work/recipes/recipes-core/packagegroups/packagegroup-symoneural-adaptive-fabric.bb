# The deployable adaptive-fabric runtime surface: every recipe in work/recipes/recipes-adaptive-fabric/ that
# produces a package. GENERATED by scripts/generate-runtime-images.py from that directory;
# a recipe added there appears here on the next run. Models and weights are never here.
SUMMARY = "SyMoNeuRaL adaptive-fabric runtime"
LICENSE = "MIT"
inherit packagegroup

RDEPENDS:${PN} = " \
    symoneural-freetoken \
"
