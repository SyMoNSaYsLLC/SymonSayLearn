# The deployable build runtime surface: every recipe in work/recipes/recipes-build/ that
# produces a package. GENERATED by scripts/generate-runtime-images.py from that directory;
# a recipe added there appears here on the next run. Models and weights are never here.
SUMMARY = "SyMoNeuRaL build runtime"
LICENSE = "MIT"
inherit packagegroup

RDEPENDS:${PN} = " \
    symoneural-bitbake \
    symoneural-openembedded-core \
"
