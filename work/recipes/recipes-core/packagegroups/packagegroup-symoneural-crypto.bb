# The deployable crypto runtime surface: every recipe in work/recipes/recipes-crypto/ that
# produces a package. GENERATED by scripts/generate-runtime-images.py from that directory;
# a recipe added there appears here on the next run. Models and weights are never here.
SUMMARY = "SyMoNeuRaL crypto runtime"
LICENSE = "MIT"
inherit packagegroup

RDEPENDS:${PN} = " \
    symoneural-stratum \
    symoneural-sv2-apps \
    symoneural-sv2-spec \
"
