# The deployable web runtime surface: every recipe in work/recipes/recipes-web/ that
# produces a package. GENERATED by scripts/generate-runtime-images.py from that directory;
# a recipe added there appears here on the next run. Models and weights are never here.
SUMMARY = "SyMoNeuRaL web runtime"
LICENSE = "MIT"
inherit packagegroup

RDEPENDS:${PN} = " \
    symoneural-workerd \
"
